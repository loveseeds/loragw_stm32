# Keil uVision project BH-F103.uvprojx, settings and files
target LoRaGw (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: loragw +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\Components\log;..\..\Components\delay;..\..\Components\Peripherals\spi;..\..\Components\Peripherals\vm_spi;..\..\Components\lora\loragw;..\..\Components\lora\loragw_spi;..\..\Components\lora\loragw_spi_port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
  group USER
    ../../User/: main.c stm32f10x_it.c stm32f10x_conf.h
  group SYS
    ../../Components/delay/: delay.c
    ../../Components/log/: log.c
  group Peripherals
    ../../Components/Peripherals/spi/: spi.c
    ../../Components/Peripherals/vm_spi/: vm_spi.c
  group LoRa
    ../../Components/lora/loragw/: loragw.c
    ../../Components/lora/loragw_spi/: loragw_spi.c
    ../../Components/lora/loragw_spi_port/: loragw_spi_port.c
